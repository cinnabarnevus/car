# Keil uVision project project.uvprojx, settings and files
target liu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\STM32F10x_FWLib\inc;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\DHT11;..\HARDWARE\BEEP;..\HARDWARE\us105;..\HARDWARE\MPU6050;..\HARDWARE\STMFLASH;..\HARDWARE\IAP;..\HARDWARE\DMA;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LCD/: GUI.c lcd.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/us105/: us105.c
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/IAP/: iap.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
